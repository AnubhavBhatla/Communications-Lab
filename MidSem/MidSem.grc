options:
  parameters:
    generate_options: qt_gui
    id: MidSem
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '441000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: 0+0
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: 1.57079+0
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abhi/Documents/EE340/MidSem/Double_SSB.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Modulated"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"(m1+m2)/2"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"(m1_cap-m2_cap)/2"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    name: '"m1"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '44100'
    fc: '0'
    fftsize: '1024'
    name: '"m2"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"m1"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_0_2, '1']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_1_1, '0']
- [blocks_add_xx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0_1, '0', blocks_add_xx_0_0, '1']
- [blocks_add_xx_0_2, '0', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0_1, '0']
- [blocks_complex_to_float_0, '1', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_add_xx_0_1, '1']
- [blocks_complex_to_float_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_complex_to_float_0_0, '1', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_sub_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_1, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_add_xx_0_2, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0_0, '0']
- [hilbert_fc_0_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', hilbert_fc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_1, '0', hilbert_fc_0_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_1_0, '0']

metadata:
  file_format: 1
