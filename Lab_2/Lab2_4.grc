options:
  parameters:
    author: abhi
    generate_options: qt_gui
    id: Lab2_4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: '960000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '1.5707963267948966'
    samp_rate: '960000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '1.5707963267948966'
    samp_rate: '960000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: '960000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_2_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '960000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abhi/Documents/EE340/Lab_2/vocal.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '11000'
    decim: '1'
    gain: '1'
    samp_rate: '960000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '11000'
    decim: '1'
    gain: '1'
    samp_rate: '960000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    size: '1024'
    srate: '960000'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    size: '1024'
    srate: '960000'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: '960000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '960000'
    interp: '44100'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '960000'
    interp: '44100'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Modulated
    label1: Demodulated
    num_tabs: '2'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_2_0, '2']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_2_0, '0']
- [analog_sig_source_x_1_0_0, '0', blocks_multiply_xx_2_1_0, '0']
- [analog_sig_source_x_1_1, '0', blocks_multiply_xx_2_1, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_2, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_2_0, '1']
- [blocks_multiply_xx_2, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_2_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_2_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_2_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_2_1_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_2_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_2_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_2_1_0, '1']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_2, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0-rc1
