options:
  parameters:
    author: abhi
    generate_options: qt_gui
    id: Lab5_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: df
  id: variable_qtgui_range
  parameters:
    label: df
    rangeType: int
    start: '-1250000'
    step: '10000'
    stop: '1250000'
    value: '20000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 1130002000-df
    samp_rate: '2048000'
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
