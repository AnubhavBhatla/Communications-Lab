options:
  parameters:
    author: abhi
    generate_options: qt_gui
    id: endsem
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(32,32*40000,10000,0.4,1408)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out0.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out1.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out2.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out3.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out4.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_4
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out5.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_5
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out6.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_6
  id: blocks_file_sink
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/out7.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abhi/Documents/EE340/EndSem/rx.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_2
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_3
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_4
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_5
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_6
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: byte
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '2'
    type: byte
  states: {}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: '3'
    type: byte
  states: {}
- name: blocks_skiphead_0_3
  id: blocks_skiphead
  parameters:
    num_items: '4'
    type: byte
  states: {}
- name: blocks_skiphead_0_4
  id: blocks_skiphead
  parameters:
    num_items: '5'
    type: byte
  states: {}
- name: blocks_skiphead_0_5
  id: blocks_skiphead
  parameters:
    num_items: '6'
    type: byte
  states: {}
- name: blocks_skiphead_0_6
  id: blocks_skiphead
  parameters:
    num_items: '7'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.000001'
    init: '0'
    low: '-0.000001'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 2*3.14159/100
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rx_taps
    type: fff
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,-0.5]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,-0.5]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: symb_rate*sps
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: '32000'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: digital
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: analog
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: digital
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: analog
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_1, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_2, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_3, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_4, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_5, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_6, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_pack_k_bits_bb_0_2, '0', blocks_file_sink_0_2, '0']
- [blocks_pack_k_bits_bb_0_3, '0', blocks_file_sink_0_3, '0']
- [blocks_pack_k_bits_bb_0_4, '0', blocks_file_sink_0_4, '0']
- [blocks_pack_k_bits_bb_0_5, '0', blocks_file_sink_0_5, '0']
- [blocks_pack_k_bits_bb_0_6, '0', blocks_file_sink_0_6, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_skiphead_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_skiphead_0_1, '0', blocks_pack_k_bits_bb_0_1, '0']
- [blocks_skiphead_0_2, '0', blocks_pack_k_bits_bb_0_2, '0']
- [blocks_skiphead_0_3, '0', blocks_pack_k_bits_bb_0_3, '0']
- [blocks_skiphead_0_4, '0', blocks_pack_k_bits_bb_0_4, '0']
- [blocks_skiphead_0_5, '0', blocks_pack_k_bits_bb_0_5, '0']
- [blocks_skiphead_0_6, '0', blocks_pack_k_bits_bb_0_6, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', iir_filter_xxx_0, '0']
- [iir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [iir_filter_xxx_0_0, '0', audio_sink_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', iir_filter_xxx_0_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', low_pass_filter_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0-rc1
